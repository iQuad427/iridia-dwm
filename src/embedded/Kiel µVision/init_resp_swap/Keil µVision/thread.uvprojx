# Keil uVision project thread.uvprojx, settings and files
target nrf52832_xxaa (5060960::V5.06 update 7 (build 960)::.\ARMCCv506u7)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.4
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x00800000,0x00010000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=5
  c define: BOARD_DW1001_DEV BSP_SIMPLE  CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 SWI_DISABLE0
  c include: ..\config;..\..\..\..\..\lib\UART;..\..\..\..\..\lib\nRF5_SDK_14.2.0\components;..\..\..\..\..\lib\nRF5_SDK_14.2.0\components\boards;..\..\..\..\..\lib\nRF5_SDK_14.2.0\components\drivers_nrf\clock;..\..\..\..\..\lib\nRF5_SDK_14.2.0\components\drivers_nrf\common;..\..\..\..\..\lib\nRF5_SDK_14.2.0\components\drivers_nrf\delay;..\..\..\..\..\lib\nRF5_SDK_14.2.0\components\drivers_nrf\gpiote;..\..\..\..\..\lib\nRF5_SDK_14.2.0\components\drivers_nrf\hal;..\..\..\..\..\lib\nRF5_SDK_14.2.0\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\lib\nRF5_SDK_14.2.0\components\drivers_nrf\spi_master;..\..\..\..\..\lib\nRF5_SDK_14.2.0\components\drivers_nrf\uart;..\..\..\..\..\lib\nRF5_SDK_14.2.0\components\libraries\atomic;..\..\..\..\..\lib\nRF5_SDK_14.2.0\components\libraries\balloc;..\..\..\..\..\lib\nRF5_SDK_14.2.0\components\libraries\bsp;..\..\..\..\..\lib\nRF5_SDK_14.2.0\components\libraries\button;..\..\..\..\..\lib\nRF5_SDK_14.2.0\components\libraries\fifo;..\..\..\..\..\lib\nRF5_SDK_14.2.0\components\libraries\experimental_log;..\..\..\..\..\lib\nRF5_SDK_14.2.0\components\libraries\experimental_log\src;..\..\..\..\..\lib\nRF5_SDK_14.2.0\components\libraries\experimental_memobj;..\..\..\..\..\lib\nRF5_SDK_14.2.0\components\libraries\experimental_section_vars;..\..\..\..\..\lib\nRF5_SDK_14.2.0\components\libraries\scheduler;..\..\..\..\..\lib\nRF5_SDK_14.2.0\components\libraries\strerror;..\..\..\..\..\lib\nRF5_SDK_14.2.0\components\libraries\timer;..\..\..\..\..\lib\nRF5_SDK_14.2.0\components\libraries\util;..\..\..\..\..\lib\nRF5_SDK_14.2.0\components\libraries\uart;..\..\..\..\..\lib\nRF5_SDK_14.2.0\components\toolchain;..\..\..\..\..\lib\nRF5_SDK_14.2.0\external\fprintf;..\..\..\..\..\lib\nRF5_SDK_14.2.0\external\segger_rtt;..\..\..\..\..\lib\nRF5_SDK_14.2.0\external\freertos\;..\..\..\..\..\lib\nRF5_SDK_14.2.0\external\freertos\source;..\..\..\..\..\lib\nRF5_SDK_14.2.0\external\freertos\config;..\..\..\..\..\lib\nRF5_SDK_14.2.0\external\freertos\source\include;..\..\..\..\..\lib\nRF5_SDK_14.2.0\external\freertos\portable\ARM\nrf52;..\..\..\..\..\lib\nRF5_SDK_14.2.0\external\freertos\portable\CMSIS\nrf52;..\..\..\..\..\lib\nRF5_SDK_14.2.0\external\freertos\source\portable;..\..\..\..\..\lib\deca_driver\port;..\..\..\..\..\lib\deca_driver;..\..\..\..\..\include\boards;..\..\..\..\..\lib\dwm;..\..\..\..\..\include\dwm;Q:\Users\quent\AppData\Local\Arm\Packs\ARM\CMSIS\4.5.0\Device\ARM\ARMCM3\Include
  asm define: BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 SWI_DISABLE0
  asm misc: --cpreproc_opts=-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DSWI_DISABLE0
  asm include: ..\..\..\..\config;..\..\..\..\..\..\..\components;..\..\..\..\..\..\..\components\boards;..\..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\components\libraries\experimental_log;..\..\..\..\..\..\..\components\libraries\experimental_log\src;..\..\..\..\..\..\..\components\libraries\experimental_memobj;..\..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\components\toolchain;..\..\..\..;..\..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\..\external\segger_rtt;..\..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x800000 size 0x10000
  link misc: --diag_suppress 6330
  group Application
    ../: main.c init_controller.c init_main.c resp_controller.c resp_main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../lib/nRF5_SDK_14.2.0/components/boards/: boards.c
  group Board Support
    ../../../../../lib/nRF5_SDK_14.2.0/components/libraries/bsp/: bsp.c bsp_nfc.c
  group nRF_Drivers
    ../../../../../lib/nRF5_SDK_14.2.0/components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../lib/nRF5_SDK_14.2.0/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../lib/nRF5_SDK_14.2.0/components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../../../../../lib/nRF5_SDK_14.2.0/components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../lib/nRF5_SDK_14.2.0/components/drivers_nrf/clock/: nrf_drv_clock.c
  group nRF_Libraries
    ../../../../../lib/nRF5_SDK_14.2.0/components/libraries/button/: app_button.c
    ../../../../../lib/nRF5_SDK_14.2.0/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../lib/nRF5_SDK_14.2.0/components/libraries/scheduler/: app_scheduler.c
    ../../../../../lib/nRF5_SDK_14.2.0/components/libraries/balloc/: nrf_balloc.c
    ../../../../../lib/nRF5_SDK_14.2.0/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../lib/nRF5_SDK_14.2.0/components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../../../lib/nRF5_SDK_14.2.0/components/libraries/strerror/: nrf_strerror.c
    ../../../../../lib/nRF5_SDK_14.2.0/components/libraries/fifo/: app_fifo.c
    ../../../../../lib/nRF5_SDK_14.2.0/components/libraries/uart/: app_uart_fifo.c retarget.c
  group nRF_Log
    ../../../../../lib/nRF5_SDK_14.2.0/components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../../../../lib/nRF5_SDK_14.2.0/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
  group Decadriver
    ../../../../../lib/deca_driver/: deca_device.c deca_params_init.c
    ../../../../../lib/deca_driver/port/: port_platform.c
  group Config
    ../../../../../lib/nRF5_SDK_14.2.0/external/freertos/config/: FreeRTOSConfig.h
  group UART
    ../../../../../lib/UART/: UART.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6, CMSIS:RTOS:Keil RTX 4.80.0, Device:Startup 8.15.4, Device:StartupConfig 8.15.4
